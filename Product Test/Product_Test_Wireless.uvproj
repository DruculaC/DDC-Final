# Keil uVision project Product_Test_Wireless.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Product_Test_Wireless +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group Product_Test_Wireless
    ./: Main_Wireless.c
  group Library
    ../Library/: voice.c UART.c pwm.c Other.c Delay.c operation.c communication.c Battery.c AD.c Timer.c
