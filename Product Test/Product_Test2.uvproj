# Keil uVision project Product_Test2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Product_Test2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group Source Group 1
    ./: Main.c Timer2.c
  group Library
    ../Library/: voice.c UART.c pwm.c Other.c Delay.c operation.c communication.c Battery.c AD.c
