# Keil uVision project DDC-F2-WXT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: DDC-F2-WXT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group DDC-F3
    ./: main.c
  group Library
    ../Library/: AD.c Battery.c communication.c Delay.c operation.c Other.c pwm.c Timer.c UART.c voice.c
