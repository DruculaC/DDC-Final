# Keil uVision project DDC-Z3-ID.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DDC-Z3-ID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group DDC-Z3-ID
    ./: Main.c
  group Library
    ../Library/: AD.c Battery.c communication.c Delay.c operation.c Other.c UART.c voice.c Timer.c
