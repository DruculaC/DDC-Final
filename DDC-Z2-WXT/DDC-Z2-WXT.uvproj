# Keil uVision project DDC-Z2-WXT.uvproj, settings and files
target Target 1 (MCS-51)
  device: N79E855 Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x000-0x3FFF) XRAM(0x00-0xFF) CLOCK(24000000) MODP2
  output: DDC-Z2-WXT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group Library
    ../Library/: AD.c Battery.c communication.c Delay.c operation.c Other.c UART.c voice.c Timer.c
  group DDC-Z4-QG
    ./: Main.c
